# Keil uVision project test.uvprojx, settings and files
target test (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\BSP\BEEP;..\BSP\KEY;..\BSP\LED;..\BSP\usart2;..\BSP\EXIT;..\BSP\TIMER;..\SYSTEM\usart;..\BSP\IIC;..\BSP\oled;..\SYSTEM\SysTick
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group BSP
    ../BSP/BEEP/: beep.c
    ../BSP/KEY/: key.c
    ../BSP/LED/: led.c
    ../BSP/EXIT/: exit.c
    ../BSP/TIMER/: timer.c
    ../BSP/oled/: oled.c
  group STM32Lib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_tim.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/SysTick/: SysTick.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
